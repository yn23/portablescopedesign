# IAR project FSMC-LCD.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\FWLib\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: FSMC-LCD.srec
  ILINK.IlinkOutputFile: FSMC-LCD.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: readme.txt
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../../FWLib/library/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_systick.c
  group User
    ../../source/: fsmc_nand.c fsmc_nor.c fsmc_sram.c lcd.c main.c menu.c sdcard.c stm32f10x_it.c
